options:
  parameters:
    author: surface
    generate_options: qt_gui
    id: rtl_433_connect
    output_language: python
    title: RTL_433 Connect
  states: {}

blocks:
- name: baseband_freq
  id: variable_qtgui_range
  parameters:
    comment: |-
      Frequency the HackRF
      is tuned to
    start: 10e6
    step: 5e6
    stop: 3000e6
    value: 433e6
  states: {}
- name: file_sink_output
  id: variable
  parameters:
    comment: |-
      The file is named such that
      rtl_433 can parse out the center
      frequency and sample rate.
    value: '"/tmp/initial-grc-output"'
  states: {}
- name: filter_bandwidth
  id: variable
  parameters:
    value: 75e3
  states: {}
- name: filter_decimation
  id: variable
  parameters:
    value: '30'
  states: {}
- name: filter_samp_rate
  id: variable
  parameters:
    comment: Filter output sample rate
    value: samp_rate / filter_decimation
  states: {}
- name: filter_transition_width
  id: variable
  parameters:
    value: 5e3
  states: {}
- name: output_file_name
  id: variable
  parameters:
    comment: |-
      The file is named such that
      rtl_433 can parse out the center
      frequency and sample rate.
    value: '"/tmp/001_" + str(tune_freq / 1e6) + "Mhz_" + "{:.3f}".format(filter_samp_rate / 1e3) + "ksps.cs16"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: tune_freq
  id: variable
  parameters:
    comment: |-
      Frequency we are 
      tuned to in software
    value: 433.95e6
  states: {}
- name: blocks_complex_to_interleaved_short_1
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: '32767'
    vector_output: 'False'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: file_sink_output
    type: short
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: tune_freq - baseband_freq
    decim: filter_decimation
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, filter_bandwidth, filter_transition_width)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '35'
    bw0: 3e6
    freq0: baseband_freq
    gain0: '15'
    gain_mode0: 'False'
    if_gain0: '40'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: filter_samp_rate
    fc: tune_freq
    fftsize: '8192'
    type: complex
    update_time: '0.025'
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: baseband_freq
    fftsize: '8192'
    type: complex
    update_time: '0.025'
  states: {state: disabled}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      # Remove the file GNU Radio creates initially.
      os.system("rm " + self.file_sink_output)

      # Create the named pipe that we will output to.
      os.system("mkfifo " + self.output_file_name)

      # Start the RTL_433 program to read from our FIFO in the background
      os.system("rtl_433 -r " + self.output_file_name + " -Y autolevel -M time:iso -M level -M protocol &")

      # Set the file sink output to use our named pipe.
      self.set_file_sink_output(self.output_file_name)
    comment: |-
      Named pipe setup code
      and execution of rtl_433
    section: main_after_init
  states: {}
- name: snippet_0_0
  id: snippet
  parameters:
    code: |-
      # Remove the named pipe
      os.system("rm " + self.output_file_name)
    comment: Named pipe cleanup code
    section: main_after_stop
  states: {}

connections:
- [blocks_complex_to_interleaved_short_1, '0', blocks_file_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_interleaved_short_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
